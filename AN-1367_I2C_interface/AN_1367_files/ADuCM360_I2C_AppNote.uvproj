# Keil uVision project ADuCM360_I2C_AppNote.uvproj, settings and files
target ADuCM360_I2C_AppNote (ARM-ADS)
  device: ADuCM360 Analog Devices
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: ADuCM360_AppNote +hex
  c flags: Optim=1
  c misc: --asm
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MainRoutine
    ./: ADuCM360StartUp.s ADuCM360_Regs.c JongSuLib_V2.c ADuCM360_Test_Lib.c ADuCM360_I2C_AppNote.c
